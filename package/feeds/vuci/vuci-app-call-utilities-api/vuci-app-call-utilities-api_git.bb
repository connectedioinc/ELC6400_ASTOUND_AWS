inherit vuci-app-api

APP_TITLE = "Call Utilities"
