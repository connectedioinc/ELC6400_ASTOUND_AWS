inherit vuci-app-ui package-bundle

APP_TITLE = "Jool"
BUNDLE_TITLE = "Jool"
