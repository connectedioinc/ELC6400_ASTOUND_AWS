inherit vuci-hs-theme

THEME_NAME = "ship"
THEME_TITLE = "Ship theme"
