inherit vuci-app-api

APP_TITLE = "VRF"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "vrf"
