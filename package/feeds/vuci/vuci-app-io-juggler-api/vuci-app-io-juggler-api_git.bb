inherit vuci-app-api

APP_TITLE = "I/O Juggler"

RDEPENDS:${PN} += "event-juggler"
