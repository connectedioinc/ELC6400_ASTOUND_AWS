inherit vuci-app-api

APP_TITLE = "MQTT"
RDEPENDS:${PN} += "mosquitto mqtt-pub"
