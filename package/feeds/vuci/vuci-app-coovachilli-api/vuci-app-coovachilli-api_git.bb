inherit vuci-app-api

APP_TITLE = "Coova Chilli"

RDEPENDS:${PN} += "coova-chilli"
