inherit vuci-app-ui

APP_TITLE = "Password Policy"
