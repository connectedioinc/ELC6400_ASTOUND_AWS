inherit vuci-app-ui package-bundle

APP_TITLE = "IGMP Proxy"
BUNDLE_TITLE = "IGMP Proxy"
