inherit vuci-app-api

APP_TITLE = "Setup Wizard"
