inherit vuci-app-api

APP_TITLE = "SQM"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "sqm-scripts"
