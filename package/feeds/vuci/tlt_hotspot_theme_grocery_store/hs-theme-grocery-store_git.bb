inherit vuci-hs-theme

THEME_NAME = "grocery_store"
THEME_TITLE = "Grocery store theme"
