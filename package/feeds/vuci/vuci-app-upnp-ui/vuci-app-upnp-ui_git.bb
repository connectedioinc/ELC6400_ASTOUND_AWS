inherit vuci-app-ui package-bundle

APP_TITLE = "UPnP"
BUNDLE_TITLE = "UPnP"
