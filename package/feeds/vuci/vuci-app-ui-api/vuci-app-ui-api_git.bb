inherit vuci-app-api

APP_TITLE = "WebUI menu info"
