inherit vuci-app-ui package-bundle

APP_TITLE = "VuCI UI Support for SNMP application"
BUNDLE_TITLE = "SNMP"
