inherit vuci-app-api

APP_TITLE = "Starlink"

RDEPENDS:${PN} += "grpcurl"
