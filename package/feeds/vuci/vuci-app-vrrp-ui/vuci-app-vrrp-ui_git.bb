inherit vuci-app-ui package-bundle

APP_TITLE = "VRRP"
BUNDLE_TITLE = "VRRP"
