inherit vuci-hs-theme

THEME_NAME = "office"
THEME_TITLE = "Office theme"
