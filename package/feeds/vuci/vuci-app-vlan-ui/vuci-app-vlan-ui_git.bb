inherit vuci-app-ui

APP_TITLE = "VLAN"
