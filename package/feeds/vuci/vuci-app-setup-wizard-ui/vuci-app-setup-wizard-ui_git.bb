inherit vuci-app-ui

APP_TITLE = "Setup Wizard"

# set-up runtime depends
RDEPENDS:${PN} += "vuci-app-ntp-ui"
