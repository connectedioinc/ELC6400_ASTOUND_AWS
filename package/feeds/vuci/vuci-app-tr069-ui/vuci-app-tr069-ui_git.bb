inherit vuci-app-ui package-bundle

APP_TITLE = "VuCI UI Support for TR-069"
BUNDLE_TITLE = "TR-069"
