inherit vuci-app-ui package-bundle

APP_TITLE = "VXLAN"
BUNDLE_TITLE = "VXLAN"

RDEPENDS:${PN} += "vuci-app-network-devices-ui"
