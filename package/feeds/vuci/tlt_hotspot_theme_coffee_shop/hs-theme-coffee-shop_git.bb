inherit vuci-hs-theme

THEME_NAME = "coffee_shop"
THEME_TITLE = "Coffee shop theme"
