inherit vuci-app-ui package-bundle

APP_TITLE = "AWS IoT Core"
BUNDLE_TITLE = "AWS IoT Core"
