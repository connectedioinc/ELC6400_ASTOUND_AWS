inherit vuci-app-api

APP_TITLE = "Overview"
