inherit vuci-app-api

APP_TITLE = "Package Manager"
