inherit vuci-app-ui

APP_TITLE = "Email Recipients"
