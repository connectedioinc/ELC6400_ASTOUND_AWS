inherit vuci-app-ui package-bundle

APP_TITLE = "VuCI UI Support for ThingWorx"
BUNDLE_TITLE = "ThingWorx"
