inherit vuci-app-ui

APP_TITLE = "Realtime Graphs"
