inherit vuci-app-ui

APP_TITLE = "Call Utilities"
