inherit vuci-app-ui

APP_TITLE = "Access control"
