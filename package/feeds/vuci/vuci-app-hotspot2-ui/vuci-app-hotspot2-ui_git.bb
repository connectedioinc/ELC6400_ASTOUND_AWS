inherit vuci-app-ui

APP_TITLE = "Hotspot 2.0"
