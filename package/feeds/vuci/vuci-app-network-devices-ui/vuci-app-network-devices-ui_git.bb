inherit vuci-app-ui

APP_TITLE = "Network devices"
