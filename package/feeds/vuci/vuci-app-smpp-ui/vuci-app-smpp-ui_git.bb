inherit vuci-app-ui package-bundle

APP_TITLE = "VuCI UI Support for SMPP"
BUNDLE_TITLE = "SMPP"
