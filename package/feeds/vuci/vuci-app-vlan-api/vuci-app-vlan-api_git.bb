inherit vuci-app-api

APP_TITLE = "VLAN"
