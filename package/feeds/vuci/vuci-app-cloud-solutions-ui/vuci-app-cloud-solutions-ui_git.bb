inherit vuci-app-ui

APP_TITLE = "Cloud Solutions"
