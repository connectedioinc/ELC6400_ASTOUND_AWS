inherit vuci-app-ui package-bundle

APP_TITLE = "RelayD"
BUNDLE_TITLE = "Relay configuration"
