inherit vuci-app-api

APP_TITLE = "Multi-Users"

RDEPENDS:${PN} += " rpcd-rpc-sys"
