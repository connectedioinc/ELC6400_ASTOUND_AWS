inherit vuci-app-api

APP_TITLE = "QoS"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "qos-scripts"
