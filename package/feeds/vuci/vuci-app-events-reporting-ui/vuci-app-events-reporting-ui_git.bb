inherit vuci-app-ui package-bundle

APP_TITLE = "Events Reporting"
BUNDLE_TITLE = "Events Reporting"
