inherit vuci-app-ui package-bundle

APP_TITLE = "Coova Chilli"
BUNDLE_TITLE = "Hotspot"
