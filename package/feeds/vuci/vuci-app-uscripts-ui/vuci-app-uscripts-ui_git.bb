inherit vuci-app-ui

APP_TITLE = "Custom User Scripts"
