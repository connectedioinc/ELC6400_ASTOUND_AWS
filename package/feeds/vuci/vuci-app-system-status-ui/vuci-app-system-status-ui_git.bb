inherit vuci-app-ui

APP_TITLE = "System Status"
