inherit vuci-app-ui

APP_TITLE = "Fota configuration"
