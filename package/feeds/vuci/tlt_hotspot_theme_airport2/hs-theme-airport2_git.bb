inherit vuci-hs-theme

THEME_NAME = "airport2"
THEME_TITLE = "Airport theme 2"
