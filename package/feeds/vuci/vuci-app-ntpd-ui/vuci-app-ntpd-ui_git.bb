inherit vuci-app-ui package-bundle

APP_TITLE = "NTPD"
BUNDLE_TITLE = "NTPD"
