inherit vuci-app-ui package-bundle

APP_TITLE = "VRF"
BUNDLE_TITLE = "VRF"
