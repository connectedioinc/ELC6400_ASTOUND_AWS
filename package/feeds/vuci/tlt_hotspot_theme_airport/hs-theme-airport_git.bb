inherit vuci-hs-theme

THEME_NAME = "airport"
THEME_TITLE = "Airport theme"
