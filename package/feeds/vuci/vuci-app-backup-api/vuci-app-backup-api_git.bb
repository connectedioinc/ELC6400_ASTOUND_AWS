inherit vuci-app-api

APP_TITLE = "Backup"

RDEPENDS:${PN} += "minizip-ng"
# todo: add minizip-ng runtime dep
