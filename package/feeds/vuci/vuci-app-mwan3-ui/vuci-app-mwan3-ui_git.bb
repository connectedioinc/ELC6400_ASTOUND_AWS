inherit vuci-app-ui package-bundle

APP_TITLE = "Multiwan"
BUNDLE_TITLE = "Failover"
