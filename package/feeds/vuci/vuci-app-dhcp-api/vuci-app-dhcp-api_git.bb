inherit vuci-app-api

APP_TITLE = "DHCP server"

RDEPENDS:${PN} += "dnsmasq"
