inherit vuci-app-ui package-bundle

APP_TITLE = "Web filter"
BUNDLE_TITLE = "Web filter"
