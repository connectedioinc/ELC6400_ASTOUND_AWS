inherit vuci-app-api

APP_TITLE = "Relayd"

RDEPENDS:${PN} += "relayd"
