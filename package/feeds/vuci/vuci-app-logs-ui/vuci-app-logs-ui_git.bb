inherit vuci-app-ui

APP_TITLE = "Logs"
