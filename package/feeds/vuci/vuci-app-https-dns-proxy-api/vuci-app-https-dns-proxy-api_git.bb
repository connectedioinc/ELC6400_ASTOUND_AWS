inherit vuci-app-api

APP_TITLE = "DNS Over HTTPS Proxy"

RDEPENDS:${PN} += "https-dns-proxy"
