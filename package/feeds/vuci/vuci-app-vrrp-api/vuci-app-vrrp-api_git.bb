inherit vuci-app-api

APP_TITLE = "VRRP"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "vrrpd"
