inherit vuci-app-api

APP_TITLE = "VuCI UI Support for Traffic Logging"

RDEPENDS:${PN} += "ulogd2"
