inherit vuci-app-ui package-bundle

APP_TITLE = "I/O Juggler"
BUNDLE_TITLE = "IO Juggler"
