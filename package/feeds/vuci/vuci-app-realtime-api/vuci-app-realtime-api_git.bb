inherit vuci-app-api

APP_TITLE = "Realtime Graphs"

RDEPENDS:${PN} += "mdcollect"
