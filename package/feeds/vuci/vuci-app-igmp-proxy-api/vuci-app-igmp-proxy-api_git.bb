inherit vuci-app-api

APP_TITLE = "IGMP Proxy"

RDEPENDS:${PN} += "igmpproxy"
