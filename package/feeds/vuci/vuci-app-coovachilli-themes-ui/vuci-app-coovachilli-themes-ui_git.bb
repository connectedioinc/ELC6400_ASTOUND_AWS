inherit vuci-app-ui

APP_TITLE = "Coova Chilli themes"
