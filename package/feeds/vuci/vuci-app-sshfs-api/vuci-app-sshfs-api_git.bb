inherit vuci-app-api

APP_TITLE = "SSHFS"

RDEPENDS:${PN} += "sshfs-fuse"
