inherit vuci-app-api

APP_TITLE = "System Status"
