inherit vuci-app-ui package-bundle

APP_TITLE = "Wifi Scanner UI"
