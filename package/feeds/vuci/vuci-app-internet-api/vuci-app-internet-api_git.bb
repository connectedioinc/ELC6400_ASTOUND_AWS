inherit vuci-app-api

APP_TITLE = "Internet status"

RDEPENDS:${PN} += "connchecker"
