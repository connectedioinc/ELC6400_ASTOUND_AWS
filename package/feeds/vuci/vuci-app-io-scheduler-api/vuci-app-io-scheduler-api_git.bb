inherit vuci-app-api

APP_TITLE = "I/O Scheduler"

RDEPENDS:${PN} += "io-scheduler"
