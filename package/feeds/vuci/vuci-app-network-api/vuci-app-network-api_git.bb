inherit vuci-app-api

APP_TITLE = "Router network"
