inherit vuci-app-ui package-bundle

APP_TITLE = "VuCI UI Support for Traffic Logging"
BUNDLE_TITLE = "Traffic Logging"
