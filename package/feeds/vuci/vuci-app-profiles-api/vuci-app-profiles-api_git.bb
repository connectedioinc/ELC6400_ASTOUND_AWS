inherit vuci-app-api

APP_TITLE = "Profiles"

# set-up runtime depends
RDEPENDS:${PN} += "profiler"
