inherit vuci-app-api

APP_TITLE = "Side Widget controller"
