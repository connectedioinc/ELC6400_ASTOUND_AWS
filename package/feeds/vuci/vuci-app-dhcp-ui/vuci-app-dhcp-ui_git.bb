inherit vuci-app-ui

APP_TITLE = "DHCP server"
