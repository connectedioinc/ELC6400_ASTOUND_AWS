inherit vuci-app-ui

APP_TITLE = "Data Sender"
