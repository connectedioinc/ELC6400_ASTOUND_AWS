inherit vuci-app-ui package-bundle

APP_TITLE = "Internet status"
BUNDLE_TITLE = "Connchecker"
