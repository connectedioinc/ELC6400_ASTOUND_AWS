inherit vuci-app-ui package-bundle

APP_TITLE = "Starlink"
BUNDLE_TITLE = "Starlink"
