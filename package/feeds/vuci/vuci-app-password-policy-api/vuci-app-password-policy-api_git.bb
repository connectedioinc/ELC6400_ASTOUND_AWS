inherit vuci-app-api

APP_TITLE = "Password Policy"
