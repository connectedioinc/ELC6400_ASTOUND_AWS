inherit vuci-app-api

APP_TITLE = "BFD"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "bfdd-frr"
