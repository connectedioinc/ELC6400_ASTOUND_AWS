inherit vuci-app-ui package-bundle

APP_TITLE = "SSHFS"
BUNDLE_TITLE = "SSHFS"
