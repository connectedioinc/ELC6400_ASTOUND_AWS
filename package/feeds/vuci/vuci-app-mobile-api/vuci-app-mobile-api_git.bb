inherit vuci-app-api

APP_TITLE = "Mobile"
