inherit vuci-app-api

APP_TITLE = "Wifi Scanner API"
RDEPENDS:${PN} += " wifi-scanner"

