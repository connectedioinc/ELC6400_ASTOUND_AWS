inherit vuci-app-api

APP_TITLE = "AWS IoT Core"

RDEPENDS:${PN} += "aws"
