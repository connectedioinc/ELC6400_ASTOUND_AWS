inherit vuci-app-ui package-bundle

APP_TITLE = "BFD"
BUNDLE_TITLE = "BFD"
