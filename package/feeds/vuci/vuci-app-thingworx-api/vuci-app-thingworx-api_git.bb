inherit vuci-app-api

APP_TITLE = "VuCI UI Support for ThingWorx"

RDEPENDS:${PN} += "thingworx"
