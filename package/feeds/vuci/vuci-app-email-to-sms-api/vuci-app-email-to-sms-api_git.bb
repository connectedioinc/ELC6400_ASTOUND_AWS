inherit vuci-app-api

APP_TITLE = "Email to SMS"

RDEPENDS:${PN} += "email-to-sms"
