inherit vuci-app-ui package-bundle

APP_TITLE = "QoS"
BUNDLE_TITLE = "Qos"
