inherit vuci-app-api

APP_TITLE = "Event Juggler"
