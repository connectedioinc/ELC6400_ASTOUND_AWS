inherit vuci-app-ui package-bundle

APP_TITLE = "PAM authentication"
BUNDLE_TITLE = "PAM"
