inherit vuci-app-ui

APP_TITLE = "Channel Analysis"
