inherit vuci-app-api

APP_TITLE = "Static routes"
