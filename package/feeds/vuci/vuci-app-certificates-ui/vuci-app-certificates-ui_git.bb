inherit vuci-app-ui

APP_TITLE = "Certificates"
