inherit vuci-app-api

APP_TITLE = "VuCI UI Support for SMPP"

RDEPENDS:${PN} += "smppd"
