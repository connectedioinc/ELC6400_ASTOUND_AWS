inherit vuci-app-api

APP_TITLE = "Coova Chilli themes"

RDEPENDS:${PN} += "vuci-app-landingpage hs-theme-default"
