inherit vuci-app-api

APP_TITLE = "Service Status"
