inherit vuci-app-ui package-bundle

APP_TITLE = "MQTT"
BUNDLE_TITLE = "MQTT"

