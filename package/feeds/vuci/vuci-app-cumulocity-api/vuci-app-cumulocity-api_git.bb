inherit vuci-app-api

APP_TITLE = "Cumulocity/Cloud of Things"
