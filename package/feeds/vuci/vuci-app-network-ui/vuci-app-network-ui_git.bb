inherit vuci-app-ui

APP_TITLE = "Router Network"
