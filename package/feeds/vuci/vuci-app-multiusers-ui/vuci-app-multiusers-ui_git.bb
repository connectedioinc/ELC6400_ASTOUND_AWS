inherit vuci-app-ui

APP_TITLE = "Multi Users"
