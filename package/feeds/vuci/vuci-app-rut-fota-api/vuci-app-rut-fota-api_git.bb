inherit vuci-app-api

APP_TITLE = "VuCI API Support for Fota configuration"

RDEPENDS:${PN} += "rutfota"
