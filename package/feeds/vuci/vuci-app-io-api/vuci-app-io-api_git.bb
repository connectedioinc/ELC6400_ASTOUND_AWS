inherit vuci-app-api

APP_TITLE = "I/O"

