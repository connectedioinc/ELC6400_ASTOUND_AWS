inherit vuci-app-api

APP_TITLE = "Firmware"

RDEPENDS:${PN} += " lua-socket"
