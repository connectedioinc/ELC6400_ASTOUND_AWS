inherit vuci-app-ui package-bundle

APP_TITLE = "Azure IoT Hub"
BUNDLE_TITLE = "Azure IoT Hub"
