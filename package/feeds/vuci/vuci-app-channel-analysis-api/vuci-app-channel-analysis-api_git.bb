inherit vuci-app-api

APP_TITLE = "Channel Analysis"
