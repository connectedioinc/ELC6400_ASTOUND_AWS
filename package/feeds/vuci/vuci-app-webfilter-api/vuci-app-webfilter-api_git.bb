inherit vuci-app-api

APP_TITLE = "Web filter"

RDEPENDS:${PN} += "host-block privoxy"
