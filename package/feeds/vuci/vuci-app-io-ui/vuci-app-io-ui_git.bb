inherit vuci-app-ui

APP_TITLE = "I/O"
