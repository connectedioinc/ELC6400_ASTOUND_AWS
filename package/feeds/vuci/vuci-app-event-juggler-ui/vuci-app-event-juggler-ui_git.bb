inherit vuci-app-ui package-bundle

APP_TITLE = "Event Juggler"
