inherit vuci-app-api

APP_TITLE = "Azure IoT Hub"

#TODO: uncomment when azure-iothub recipe is created
#RDEPENDS:${PN} += "azure-iothub vuci-app-data-sender-api-mod-azure"
