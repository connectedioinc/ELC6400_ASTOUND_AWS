inherit vuci-app-api

APP_TITLE = "Access Control"

RDEPENDS:${PN} += " ip-blockd"
