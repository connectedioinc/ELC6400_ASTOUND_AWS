inherit vuci-app-api

APP_TITLE = "Troubleshoot"

# todo: add minizip-ng runtime dep
