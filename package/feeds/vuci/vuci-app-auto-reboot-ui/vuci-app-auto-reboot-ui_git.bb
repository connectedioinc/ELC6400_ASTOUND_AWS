inherit vuci-app-ui

APP_TITLE = "Auto Reboot"
