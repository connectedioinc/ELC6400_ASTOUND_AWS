inherit vuci-app-ui package-bundle

APP_TITLE = "SQM"
BUNDLE_TITLE = "SQM"
