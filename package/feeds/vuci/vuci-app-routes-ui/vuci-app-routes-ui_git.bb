inherit vuci-app-ui

APP_TITLE = "Static routes"
