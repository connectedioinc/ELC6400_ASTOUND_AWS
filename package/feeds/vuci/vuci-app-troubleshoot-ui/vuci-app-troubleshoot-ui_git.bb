inherit vuci-app-ui

APP_TITLE = "Troubleshoot"

# todo: require troubleshoot package?
