inherit vuci-hs-theme

THEME_NAME = "bus"
THEME_TITLE = "Bus theme"
