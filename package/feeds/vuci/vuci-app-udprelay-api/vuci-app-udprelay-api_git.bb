inherit vuci-app-api

APP_TITLE = "UDP relay"

# Uncomment when package becomes available
# RDEPENDS:${PN} += "udprelay"
