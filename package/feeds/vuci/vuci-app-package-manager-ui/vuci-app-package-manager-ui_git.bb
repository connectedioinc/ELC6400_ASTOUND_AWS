inherit vuci-app-ui

APP_TITLE = "Package Manager"
