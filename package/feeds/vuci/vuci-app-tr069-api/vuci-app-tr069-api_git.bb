inherit vuci-app-api

APP_TITLE = "VuCI UI Support for TR-069"

RDEPENDS:${PN} += "easycwmp"
