inherit vuci-app-ui package-bundle

APP_TITLE = "Cumulocity/Cloud of Things"
BUNDLE_TITLE = "Cumulocity & Cloud of Things"

RDEPENDS:${PN} += "cm-stream"
