inherit vuci-app-api

APP_TITLE = "NTPD"

RDEPENDS:${PN} += "ntp"
