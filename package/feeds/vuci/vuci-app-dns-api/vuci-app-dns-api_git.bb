inherit vuci-app-api

APP_TITLE = "DNS"
