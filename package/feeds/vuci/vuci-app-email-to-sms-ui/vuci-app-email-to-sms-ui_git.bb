inherit vuci-app-ui package-bundle

APP_TITLE = "Email to SMS"
BUNDLE_TITLE = "Email to SMS"
