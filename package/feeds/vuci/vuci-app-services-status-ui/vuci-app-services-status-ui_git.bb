inherit vuci-app-ui

APP_TITLE = "Service Status"
