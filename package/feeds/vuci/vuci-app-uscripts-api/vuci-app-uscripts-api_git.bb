inherit vuci-app-api

APP_TITLE = "Custom User Scripts"
