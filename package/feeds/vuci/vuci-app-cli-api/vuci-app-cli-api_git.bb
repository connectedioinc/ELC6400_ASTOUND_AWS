inherit vuci-app-api

APP_TITLE = "CLI"

RDEPENDS:${PN} += " shellinabox"
