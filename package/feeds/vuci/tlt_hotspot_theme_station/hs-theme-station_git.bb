inherit vuci-hs-theme

THEME_NAME = "station"
THEME_TITLE = "Train station theme"
