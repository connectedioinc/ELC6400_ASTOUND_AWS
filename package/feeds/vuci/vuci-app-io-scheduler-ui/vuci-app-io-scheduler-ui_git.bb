inherit vuci-app-ui package-bundle

APP_TITLE = "I/O Scheduler"
BUNDLE_TITLE = "Input/Output Scheduler"
