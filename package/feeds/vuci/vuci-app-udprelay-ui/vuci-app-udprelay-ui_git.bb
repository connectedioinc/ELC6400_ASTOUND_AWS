inherit vuci-app-ui package-bundle

APP_TITLE = "UDP Broadcast Relay"
BUNDLE_TITLE = "UDP Broadcast Relay"
