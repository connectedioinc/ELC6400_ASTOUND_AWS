inherit vuci-hs-theme

THEME_NAME = "park"
THEME_TITLE = "Park theme"
