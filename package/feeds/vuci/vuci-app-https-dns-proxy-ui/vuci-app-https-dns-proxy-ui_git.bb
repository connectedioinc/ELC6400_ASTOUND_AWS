inherit vuci-app-ui package-bundle

APP_TITLE = "HTTPS DNS Proxy"
BUNDLE_TITLE = "HTTPS DNS Proxy"
