inherit vuci-app-api

APP_TITLE = "OPENVPN"

RDEPENDS:${PN} += " openvpn"
