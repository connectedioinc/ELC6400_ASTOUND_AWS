inherit vuci-app-api

APP_TITLE = "Auto Reboot"
