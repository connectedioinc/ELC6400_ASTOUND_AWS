inherit vuci-app-api

APP_TITLE = "Multiwan"

RDEPENDS:${PN} += "mwan3"
